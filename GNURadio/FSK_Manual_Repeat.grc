options:
  parameters:
    author: Drew Pearlstein
    description: FSK_Mod_Demod updated
    generate_options: qt_gui
    id: FSK_Mod_Demod_SDR
    output_language: python
    title: FSK_Mod_Demod_SDR
  states: {}

blocks:
- name: SEND_GPS
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: center
  id: variable
  parameters:
    value: '2465230000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: h*baud/2
  states: {}
- name: h
  id: variable
  parameters:
    value: '1.2'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: ((center+(fsk_deviation/2))/vco_max)-vco_offset
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: pack_len
  id: variable
  parameters:
    value: '21'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '3520'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*baud
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-20'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '"~e40.476400,-74.025400            "'
  states: {}
- name: variable_repetition_decoder_def_0
  id: variable_repetition_decoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: variable_repetition_encoder_def_0
  id: variable_repetition_encoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
    rep: '3'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: (center-(fsk_deviation/2))/vco_max
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: vco_offset
    const: vco_offset
    type: float
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\thech\OneDrive\Documents\recievedmessage.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\drewi\OneDrive\Desktop\torrent\fskSDR\check.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\drewi\OneDrive\Desktop\torrent\demodMessage.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: C:\Users\drewi\OneDrive\Desktop\torrent\demodMessage.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Drew\Desktop\torrent\fskSDR\originalMessage.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: inp_amp
    const: inp_amp
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pack_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pack_len
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '.5'
    samp_rate: samp_rate
    sensitivity: '15708'
  states: {state: disabled}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_diff_encoder_bb_1
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"burst"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    comment: This block uses the input stream to format a header and payload for the output stream automatically. We can append data to the header as necessary.
    format: hdr_format
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr
      import collections


      # def binatodeci(binary):
      #    return sum(val * (2 ** idx) for idx, val in enumerate(reversed(binary)))


      def convertToAscii(binary_list):
          # Convert binary list to string
          binary_string = ''.join(map(str, binary_list))

          # Split binary string into 8-bit chunks
          binary_chunks = [binary_string[i:i + 8] for i in range(0, len(binary_string), 8)]

          # Convert each 8-bit chunk to ASCII character and print its decimal value
          for chunk in binary_chunks:
              ascii_char = chr(int(chunk, 2))
              ascii_decimal = ord(ascii_char)
              # print(ascii_decimal, end=' ')

          chunk = 0

          # for chunk in binary_chunks:
          #     print(ascii_char, end=' ')

          # Convert each 8-bit chunk to ASCII character
          ascii_string = ''.join([chr(int(chunk, 2)) for chunk in binary_chunks])
          return ascii_string


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Look For Packet',  # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Header = collections.deque([0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0], maxlen=16)
              self.buffer = collections.deque(maxlen=16)
              self.message = collections.deque(maxlen=176)
              self.foundHeader = False
              self.lengthCount = 0
              self.maxLength = 25
              self.nb = []

          def work(self, input_items, output_items):
              self.buffer.append(input_items[0][0])
              if len(self.buffer) == 16:
                  if self.buffer == self.Header and self.foundHeader is False:
                      print("Found 25")
                      # print(str(self.buffer))
                      self.nb = list(self.buffer)
                      self.foundHeader = True

                  elif self.foundHeader is True:
                      if len(self.message) < 176:
                          self.message.append(input_items[0][0])
                      elif len(self.message) == 176:
                          self.foundHeader = False
                          self.message = convertToAscii(list(self.message))
                          print(self.message)
                          self.buffer = collections.deque([], maxlen=16)
                      else:
                          print("Haven't Found header")

      #        return (self.message))
              return 0


      """
                  if self.foundHeader is True and self.lengthCount < self.maxLength * 8:
                      output_items[0][:] = input_items[0][:]
                      self.lengthCount += 1
                  elif self.foundHeader is True:
                      output_items[0] = np.insert(output_items[0], 0, self.nb)
                      print("end of message")
                      self.foundHeader = False
                      self.lengthCount = 0
                      self.buffer = []
      """
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Multiplexer',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
       

          def work(self, input_items, output_items):
              """example: multiply with constant"""

              output_items[0][:] = input_items[0] + input_items[1]
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print To Screen',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.printItems = True
              self.butt = False
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              chararray = [chr(i) for i in input_items[0]]
              if self.butt is False:
                  print("Header Is", input_items[0])
                  self.butt = True
              if self.printItems is False:
                  print(''.join(chararray))
                  self.printItems = True
              return 0
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import collections
      import threading



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print To Screen',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.printItems = False
              self.butt = True
              # self.header = collections.deque(maxlen=4)
              # self.message = collections.deque(maxlen=22)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #last_byte = input_items[0][0]
              #self.message.append(last_byte)
              #if len(self.message) == 4:

              input_items[0] = input_items[0][4:26]
              chararray = [chr(i) for i in input_items[0]]
              if self.butt is False:
                  print("Header Is", input_items[0])
                  self.butt = True
              if self.printItems is False:
                  print(''.join(chararray))
                  self.printItems = True
              return 0
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    GPS: 'False'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, GPS=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Send Message Again',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.GPS = GPS

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0][:]

              # return len(output_items[0])
              return output_items[0]
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Creates a tag for the packet of data that contains the data type and size
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Converts the tagged stream back into readable data
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '16384'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*(fsk_deviation + baud)
    center_freq0: center
    dev_addr: '"serial=31E9D65"'
    gain0: '120'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*(fsk_deviation + baud)
    center_freq0: center
    dev_addr: '"serial=323098E"'
    gain0: '150'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*(fsk_deviation + baud)
    center_freq0: center
    dev_addr: '"serial=323098E"'
    gain0: '40'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*(fsk_deviation + baud)
    center_freq0: center
    dev_addr: '"serial=31E9D65"'
    gain0: '150'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '"xmt_data"'
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '"xmt_data"'
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '"xmt_data"'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', epy_block_1, '0']
- [analog_noise_source_x_1, '0', blocks_stream_mux_0, '1']
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_file_source_0, '0', epy_block_3, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_3, '0']
- [blocks_repack_bits_bb_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_tag_debug_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_gfsk_mod_0, '0']
- [blocks_repack_bits_bb_1_1, '0', epy_block_2, '0']
- [blocks_repack_bits_bb_1_1, '0', epy_block_2_0, '0']
- [blocks_repack_bits_bb_1_1_0, '0', epy_block_2_0, '0']
- [blocks_stream_mux_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_1_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_header_payload_demux_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_throttle_0, '0', digital_gfsk_mod_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_crc32_async_bb_0_0, out, blocks_message_debug_1, print]
- [digital_crc32_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', epy_block_0, '0']
- [digital_diff_decoder_bb_1, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_throttle_0, '0']
- [digital_diff_encoder_bb_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_gfsk_mod_0, '0', blocks_stream_mux_0, '0']
- [digital_gfsk_mod_0, '0', epy_block_1, '1']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_gfsk_mod_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1_1_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [epy_block_1, '0', digital_gfsk_demod_0, '0']
- [epy_block_3, '0', digital_diff_encoder_bb_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_protocol_formatter_async_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc32_async_bb_0_0, in]
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0_0, '0', analog_simple_squelch_cc_0, '0']
- [virtual_source_0, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_0, '0', digital_gfsk_demod_0, '0']
- [virtual_source_0_0, '0', digital_diff_decoder_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
